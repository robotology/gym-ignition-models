Commit message: Change base iCub link to have x-forward and z-upward

File: gym_ignition_models/iCubGazeboV2_5/icub.urdf (robot description, URDF)
Before this commit: robot iCubGazeboV2_5, 52 links, 51 joints
Joints:
- joint base_fixed_joint: origin xyz=0 0 0 rpy=0 -0 0 -> xyz=0 0 0 rpy=0 0 3.14
